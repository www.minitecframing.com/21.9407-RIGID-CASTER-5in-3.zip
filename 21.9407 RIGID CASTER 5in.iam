# Autodesk Inventor assembly: 21.9407
## iProperties
Created: 2012-08
Part Number: 21.9407
Document SubType Name: Assembly
Designer: Administrator
Description: RIGID CASTER 5in
Author: Administrator
